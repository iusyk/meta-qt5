PACKAGECONFIG[wayland-layer-integration-vsp2] = "-feature-wayland-layer-integration-vsp2,-no-feature-wayland-layer-integration-vsp2"
PACKAGECONFIG += "wayland-server wayland-layer-integration-vsp2"