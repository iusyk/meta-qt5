PACKAGECONFIG += "geoservices_mapboxgl"