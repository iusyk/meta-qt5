FILES_${PN}-dev += " \
    ${OE_QMAKE_PATH_DATA}/cmake/* \
"
